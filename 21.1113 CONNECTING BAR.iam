# Autodesk Inventor assembly: 21.1113 CONNECTING BAR
## iProperties
Created: 2007-01
Part Number: 21.1113 CONNECTING BAR
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
